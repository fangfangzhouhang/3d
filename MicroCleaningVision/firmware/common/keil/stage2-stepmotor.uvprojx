# Keil uVision project stage2-stepmotor.uvprojx, settings and files
target stage2-stepmotor (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: stage2-stepmotor +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\board;..;..\..\pump;..\..\motion;C:\Keil_v5\ARM\PACK\Keil\STM32F1xx_DFP\2.2.0\Device\Include;C:\Keil_v5\ARM\PACK\Keil\STM32F1xx_DFP\2.2.0\Device\StdPeriph_Driver\inc;C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.0.1\CMSIS\Include;..\safety;..\compat\stage1\system_b;..\serial
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group stage2-stepmotor app
    ../: main.c
    ../board/: stm32f103_hal.c stm32f10x_it.c
    ../../motion/: stepmotor.c
    ../../pump/: pump.c
    ../safety/: control_core.c
    ../serial/: mcv1_protocol.c
  group stage2-stepmotor startup
    C:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/2.2.0/Device/Source/ARM/: startup_stm32f10x_md.s
  group stage2-stepmotor spl
    C:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/2.2.0/Device/Source/: system_stm32f10x.c
    C:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/2.2.0/Device/StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
