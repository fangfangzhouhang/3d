# Keil uVision project f103-stage1.uvprojx, settings and files
target f103-stage1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: f103-stage1 +hex
  c flags: Optim=4 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\compat\stage1\driver_a;..\compat\stage1\system_b;..\compat\stage1\common;..\..\..\..\..\Keil_v5\ARM\PACK\Keil\STM32F1xx_DFP\2.4.1\Device\Include;..\..\..\..\..\Keil_v5\ARM\PACK\Keil\STM32F1xx_DFP\2.4.1\Device\StdPeriph_Driver\inc;..\..\..\..\..\Keil_v5\ARM\PACK\ARM\CMSIS\5.8.0\CMSIS\Core\Include;..\safety;..\compat\stage1\system_b;..\serial
  library: MicroLIB
  group f103-stage1 app
    ../compat/stage1/common/: main.c
    ../compat/stage1/driver_a/: stm32f103_hal.c uart_rx_guard.c stm32f10x_it.c
    ../safety/: control_core.c
    ../serial/: mcv1_protocol.c
    ../compat/stage1/system_b/: command_parser.c protocol.c line_receiver.c
  group f103-stage1 startup
    ../../../../../Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/2.4.1/Device/Source/ARM/: startup_stm32f10x_md.s
  group f103-stage1 spl
    ../../../../../Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/2.4.1/Device/Source/: system_stm32f10x.c
    ../../../../../Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/2.4.1/Device/StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
